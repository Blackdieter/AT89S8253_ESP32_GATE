# Keil uVision project 8051_GATE.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT83C5134 Microchip
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x1FFF) CLOCK(24000000) MODP2
  output: 8051_GATE +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main Group
    ./: D_INTERUPTS.a51
target Target component (MCS-51)
  device: AT89S8253 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x2FFF) CLOCK(24000000) MODA2
  output: 8051_GATE +hex
  c flags: Optimize=8 SizeSpeed=1
