# Keil uVision project DEMO.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: DEMO +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: SWEEP_01_09.a51
target Target 2 C52 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DEMO +hex
  c flags: Optimize=8 SizeSpeed=1
